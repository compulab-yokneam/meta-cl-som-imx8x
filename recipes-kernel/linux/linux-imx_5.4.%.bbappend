FILESEXTRAPATHS_prepend := "${THISDIR}/compulab/cl-som-imx8x:"

require compulab/cl-som-imx8x.inc

KERNEL_MODULE_AUTOLOAD += "goodix"
