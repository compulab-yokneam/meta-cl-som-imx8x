PV = "3.8.5"

SRC_URI[md5sum] = "c1797407517b0499f6d5151c1e62e78f"
SRC_URI[sha256sum] = "b8731c626139c9bd1d530f243c2131c031a523f1428c6a40b017e5352b1da656"

do_populate_lic[noexec] = "1"
