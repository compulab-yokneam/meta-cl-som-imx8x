do_deploy[noexec] = "1"

DEPENDS = "scfw"

