FILESEXTRAPATHS_prepend := "${THISDIR}/cl-som-imx8x:"

SRC_URI_append = " file://0001-cl-som-imx8x-allow-access-to-SC_R_SYSTEM-in-order-to.patch"
