require compulab/cl-som-imx8x.inc
