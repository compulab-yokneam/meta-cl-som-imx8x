FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES = "file://compulab-logo-portrait-img.h;outsuffix=default"
